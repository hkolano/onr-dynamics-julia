Commit message: implemented buoyancy *correctly

File: URDFs/alphaArmFixedJaws.urdf (robot description, URDF)
Before this commit: robot reach5mini, 9 links, 8 joints
Links:
- link r5m_jaw1: mass 0.05 -> 0.00
- link r5m_jaw2: mass 0.05 -> 0.0
